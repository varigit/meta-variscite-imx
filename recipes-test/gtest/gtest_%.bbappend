SRC_URI = "git://github.com/google/googletest.git;protocol=https;branch=main"
