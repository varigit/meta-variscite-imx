FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-tclap-change-source-package-fetching-due-to-CAF-bein.patch"
