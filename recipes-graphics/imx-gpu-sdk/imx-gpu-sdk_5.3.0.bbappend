DEPENDS_append_mx8qxp = " rapidopenvx"

