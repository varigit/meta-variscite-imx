SRC_URI_remove = "git://github.com/KhronosGroup/SPIRV-Tools;protocol=http;name=spirv-tools"
SRC_URI_prepend = "git://github.com/KhronosGroup/SPIRV-Tools;protocol=http;branch=main;name=spirv-tools "
