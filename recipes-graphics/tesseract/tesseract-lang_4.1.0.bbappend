SRC_URI = "git://github.com/tesseract-ocr/tessdata.git;branch=main"
