SRC_URI = "git://github.com/tesseract-ocr/tessdata.git;protocol=https;branch=main"
