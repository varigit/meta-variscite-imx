SRC_URI = "git://github.com/KhronosGroup/glslang;protocol=https;branch=main"
