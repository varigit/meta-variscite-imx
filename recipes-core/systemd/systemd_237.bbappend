SRC_URI_remove = "git://github.com/systemd/systemd.git;protocol=git"
SRC_URI_append = "git://github.com/systemd/systemd.git;protocol=https;branch=main"
