SRC_URI_remove = "git://git.code.sf.net/p/tclap/code"
SRC_URI_append = "git://git.code.sf.net/p/tclap/code;protocol=https;branch=1.2"
