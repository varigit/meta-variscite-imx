SRC_URI = "git://github.com/onnx/onnx.git;protocol=https;branch=main"
