COMPATIBLE_MACHINE = "(imx8mp)"
