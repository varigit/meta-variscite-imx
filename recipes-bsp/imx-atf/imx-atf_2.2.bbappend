SRC_URI = "git://github.com/varigit/imx-atf;protocol=git;branch=${SRCBRANCH}"
SRCBRANCH = "imx_5.4.70_2.3.2_var01"
SRCREV = "a00e695cb1eda1c84e4e941ea561eca85975e0cd"


