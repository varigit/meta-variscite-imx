SRC_URI = "git://github.com/varigit/imx-atf;protocol=git;branch=${SRCBRANCH}"
SRCBRANCH = "lf_v2.4_var01"
SRCREV = "04d7bb82577d13b28de2c0cf33bfaa5c05b628ec"


