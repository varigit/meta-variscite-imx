SRC_URI = "http://pkgs.fedoraproject.org/repo/pkgs/logrotate/logrotate-3.9.1.tar.gz/4492b145b6d542e4a2f41e77fa199ab0/logrotate-${PV}.tar.gz \
           file://act-as-mv-when-rotate.patch \
           file://update-the-manual.patch \
           file://disable-check-different-filesystems.patch \
            "
