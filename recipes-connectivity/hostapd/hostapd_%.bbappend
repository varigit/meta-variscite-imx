FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

updatercd_preinst() {
    :
}

updatercd_postinst() {
    :
}
