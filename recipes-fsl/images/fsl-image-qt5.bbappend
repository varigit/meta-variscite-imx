IMAGE_INSTALL += " \
    util-linux-sfdisk \
    u-boot-splash \
    u-boot-fw-utils \
    "
